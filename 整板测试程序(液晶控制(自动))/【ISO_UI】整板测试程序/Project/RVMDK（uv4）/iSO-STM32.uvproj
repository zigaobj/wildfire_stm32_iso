# Keil uVision project iSO-STM32.uvproj, settings and files
target ISO整板测试-触摸控制 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=2 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Led;..\..\User\Lcd;..\..\User\usart;..\..\User\i2c;..\..\User\touch;..\..\User\SysTick;..\..\User\led;..\..\User\key;..\..\User\spi;..\..\User\iso;..\..\User\dht11;..\..\User\ds18b20;..\..\User\ov7725;..\..\User\adc;..\..\User\breathinglight;..\..\User\rda5807m;..\..\User\enc28j60;..\..\User\can;..\..\User\rtc;..\..\User\sram;..\..\User\norflash;..\..\User\usb\Mass_Storage\inc;..\..\User\usb\STM32_USB-FS-Device_Driver\inc;..\..\User\usb;..\..\User\sdcard;..\..\User\nandflash;..\..\User\ff9;..\..\User\ff9\option;..\..\User\iis;..\..\User\pcm1770;..\..\User\mp3\pub
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group BSP-ISO
    ../../User/iso/: bsp_iso_test.c
  group BSP-USART
    ../../User/usart/: bsp_usart1.c
  group BSP-液晶显示
    ../../User/Lcd/: bsp_ili9341_lcd.c
  group BSP-EEPROM
    ../../User/i2c/: bsp_i2c_gpio.c bsp_i2c_ee.c
  group BSP-液晶触摸
    ../../User/touch/: bsp_gpio_spi.c bsp_touch.c
  group BSP-SysTick
    ../../User/SysTick/: bsp_SysTick.c
  group BSP-LED
    ../../User/led/: bsp_led.c
  group BSP-KEY
    ../../User/key/: bsp_key.c
  group BSP-FLASH
    ../../User/spi/: bsp_spi_flash.c
  group BSP-DHT11
    ../../User/dht11/: bsp_dht11.c
  group BSP-DS18B20
    ../../User/ds18b20/: bsp_ds18b20.c
  group BSP-摄像头（火眼OV7725）
    ../../User/ov7725/: bsp_ov7725.c bsp_sccb.c
  group BSP-FM
    ../../User/rda5807m/: bsp_rda5807m.c
  group BSP-RTC（万年历）
    ../../User/rtc/: bsp_calendar.c bsp_date.c bsp_rtc.c
  group BSP-ADC
    ../../User/adc/: bsp_adc.c
  group BSP-以太网ENC28J60
    ../../User/enc28j60/: enc28j60.c ip_arp_udp_tcp.c spi_enc28j60.c web_server.c enc28j60_test.c
  group 呼吸灯
    ../../User/breathinglight/: bsp_breathing.c
  group BSP-CAN（loopback）
    ../../User/can/: bsp_can.c
  group BSP-SRAM
    ../../User/sram/: bsp_fsmc_sram.c
  group BSP-NORFLASH
    ../../User/norflash/: bsp_fsmc_nor.c
  group BSP-UsbMassStorage
    ../../User/usb/: bsp_UsbMassStorage.c
  group STM32_USB-FS-Device_Driver
    ../../User/usb/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Mass_Storage
    ../../User/usb/Mass_Storage/src/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group BSP-SDCARD
    ../../User/sdcard/: bsp_sdio_sdcard.c bsp_bmp.c bsp_sdfs_app.c
  group BSP-NAND
    ../../User/nandflash/: bsp_nand.c
  group BSP_IIS
    ../../User/iis/: bsp_iis.c
  group BSP_PCM
    ../../User/pcm1770/: bsp_pcm1770.c
  group ff9
    ../../User/ff9/: diskio.c ff.c
    ../../User/ff9/option/: ccsbcs.c
  group APP-UI
    ../../User/: app_ui.c mp3.c
  group mp3
    ../../User/mp3/: mp3dec.c mp3tabs.c
    ../../User/mp3/real/: trigtabs.c bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c
    ../../User/mp3/real/arm/: asmmisc.s asmpoly_thumb2.s
